# Keil uVision project Driver_1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Driver_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPPERIPH_DRIVER
  c include: ..\Driver1;.\STM32F10x_StdPeriph_Driver\inc;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c main.h controller.c can.c Proximity_LS_IO.c
  group MDK_ARM
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Libs
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_flash.c
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
